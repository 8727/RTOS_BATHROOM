# Keil uVision project RTOS_BATHROOM_v1_1.uvprojx, settings and files
target RTOS_BATHROOM_v1_1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RTOS_BATHROOM_v1_1 +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\RTOS_BATHROOM;.\CMSIS\inc;..\SOURCE\inc;..\FreeRTOS\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/src/: core_cm3.c system_stm32f10x.c
  group StartUp
    ./CMSIS/StartUp/: startup_stm32f10x_md.s
  group FreeRTOS
    ../FreeRTOS/src/: croutine.c event_groups.c heap_4.c list.c port.c queue.c stream_buffer.c tasks.c timers.c
  group Source
    ../SOURCE/src/: main.c sysInit.c setting.c rtc.c nRF24L01.c i2c.c eeprom.c
